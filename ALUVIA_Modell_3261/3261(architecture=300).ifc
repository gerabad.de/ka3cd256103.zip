Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_576/temp/tmp_1656_32_u3E9w/format_0/3261(architecture=300).ifc
Time: 2025-09-01T09:05:22
Made in: PARTsolutions

# IfcProject, 3261(architecture=300)
Description: ALUVIA

# IfcDiscreteAccessory, 3261(architecture=300)
In: BUILDING
Description: 3261(architecture=300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 3261
ePset_PARTsolutions - NB: 3261(architecture=300); NN: 3261; NT: ALUVIA; NBSYN: $A.($LODDEST.=$LODLEVEL.); LINA: 3261(architecture=300); CATALOG: Kaldewei; LODLEVEL: 300; A: 3261; B: 3261_aluvia_900x1000.png; C: ALUVIA; E: KALDEWEI; EF000049: 900; EF004567: 1000; etim7_EC003246: EC003246; etim7_EC003246_WIDTH: 1000; etim7_EC003246_LENGTH: 900
